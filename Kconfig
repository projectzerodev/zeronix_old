## Kconfig
```kconfig
mainmenu "Zeronix Kernel"

menu "Debugging"

config PAGING_DEBUG
    bool "Enable Paging Debugging"
    default n

endmenu # Debugging
```
